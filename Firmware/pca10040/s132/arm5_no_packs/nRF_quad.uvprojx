# Keil uVision project nRF_quad.uvprojx, settings and files
target nrf52832_xxaa_s132 (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nrf52832_xxaa_s132 +hex
  c flags: Optim=1 OneElfS=1
  c define: DEBUG BLE_STACK_SUPPORT_REQD NRF52_PAN_53 NRF52_PAN_15 NRF52_PAN_54 NRF52_PAN_20 NRF52_PAN_55 NRF52_PAN_30 NRF52_PAN_58 NRF52_PAN_31 NRF52_PAN_62 NRF52_PAN_36 NRF52_PAN_63 NRF52_PAN_51 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET BOARD_PCA10040 NRF52_PAN_12 S132 NRF_LOG_USES_RTT=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0 DEBUG
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\nRF5_SDK_11.0.0\components\ble\ble_advertising;..\..\..\..\nRF5_SDK_11.0.0\components\ble\ble_services\ble_nus;..\..\..\..\nRF5_SDK_11.0.0\components\ble\common;..\..\..\..\nRF5_SDK_11.0.0\components\drivers_ext\segger_rtt;..\..\..\..\nRF5_SDK_11.0.0\components\drivers_nrf\common;..\..\..\..\nRF5_SDK_11.0.0\components\drivers_nrf\config;..\..\..\..\nRF5_SDK_11.0.0\components\drivers_nrf\delay;..\..\..\..\nRF5_SDK_11.0.0\components\drivers_nrf\gpiote;..\..\..\..\nRF5_SDK_11.0.0\components\drivers_nrf\hal;..\..\..\..\nRF5_SDK_11.0.0\components\drivers_nrf\pstorage;..\..\..\..\nRF5_SDK_11.0.0\components\drivers_nrf\uart;..\..\..\..\nRF5_SDK_11.0.0\components\libraries\button;..\..\..\..\nRF5_SDK_11.0.0\components\libraries\fifo;..\..\..\..\nRF5_SDK_11.0.0\components\libraries\timer;..\..\..\..\nRF5_SDK_11.0.0\components\libraries\trace;..\..\..\..\nRF5_SDK_11.0.0\components\libraries\uart;..\..\..\..\nRF5_SDK_11.0.0\components\libraries\util;..\..\..\..\nRF5_SDK_11.0.0\components\softdevice\common\softdevice_handler;..\..\..\..\nRF5_SDK_11.0.0\components\softdevice\s132\headers;..\..\..\..\nRF5_SDK_11.0.0\components\softdevice\s132\headers\nrf52;..\..\..\..\nRF5_SDK_11.0.0\components\toolchain;..\..\..\..\nRF5_SDK_11.0.0\examples\bsp;..\..\..\..\nrf52-quadcopter;..\..\..\bitcraze_modules\interface;..\..\..\..\nRF5_SDK_11.0.0\components\drivers_nrf\pwm;..\..\..\..\nRF5_SDK_11.0.0\components\drivers_nrf\clock;..\..\..\drivers;..\..\..\..\nRF5_SDK_11.0.0\external\segger_rtt;..\..\..\..\nRF5_SDK_11.0.0\components\libraries\fstorage;..\..\..\..\nRF5_SDK_11.0.0\components\libraries\fstorage\config;..\..\..\..\nRF5_SDK_11.0.0\components\libraries\experimental_section_vars;..\..\..\..\nRF5_SDK_11.0.0\components\ble\ble_debug_assert_handler;..\..\..\..\nRF5_SDK_11.0.0\components\ble\ble_error_log;..\..\..\..\nRF5_SDK_11.0.0\components\drivers_nrf\ble_flash;..\..\..\modules;..\..\..\..\nRF5_SDK_11.0.0\components\drivers_nrf\twi_master;..\..\..\..\nRF5_SDK_11.0.0\components\ble\ble_radio_notification;..\..\..\..\nRF5_SDK_11.0.0\components\drivers_nrf\pstorage
  asm define: BLE_STACK_SUPPORT_REQD NRF52_PAN_53 NRF52_PAN_15 NRF52_PAN_54 NRF52_PAN_20 NRF52_PAN_55 NRF52_PAN_30 NRF52_PAN_58 NRF52_PAN_31 NRF52_PAN_62 NRF52_PAN_36 NRF52_PAN_63 NRF52_PAN_51 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET BOARD_PCA10040 NRF52_PAN_12 S132 NRF_LOG_USES_UART=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x50000
  memory RVCT9: RAM 0x20001fe8 size 0xe018
  group Application
    ../../../: main.c stabilizer.c command_input.c motor.c imu_toplevel.c
    ../../../bitcraze_modules/src/: pid.c controller.c
    ../../../drivers/: pm.c quadcopter.c advertising.c
  group Board Support
    ../../../../nRF5_SDK_11.0.0/examples/bsp/: bsp.c bsp_btn_ble.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../nRF5_SDK_11.0.0/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../nRF5_SDK_11.0.0/components/ble/ble_advertising/: ble_advertising.c
    ../../../../nRF5_SDK_11.0.0/components/ble/ble_services/ble_nus/: ble_nus.c
    ../../../../nRF5_SDK_11.0.0/components/ble/ble_radio_notification/: ble_radio_notification.c
  group nRF_Drivers
    ../../../../nRF5_SDK_11.0.0/components/libraries/uart/: app_uart_fifo.c
    ../../../../nRF5_SDK_11.0.0/components/drivers_nrf/delay/: nrf_delay.c
    ../../../../nRF5_SDK_11.0.0/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../nRF5_SDK_11.0.0/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../nRF5_SDK_11.0.0/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../nRF5_SDK_11.0.0/components/drivers_nrf/pwm/: nrf_drv_pwm.c
    ../../../../nRF5_SDK_11.0.0/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../nRF5_SDK_11.0.0/components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../nRF5_SDK_11.0.0/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../nRF5_SDK_11.0.0/components/libraries/button/: app_button.c
    ../../../../nRF5_SDK_11.0.0/components/libraries/util/: app_error.c nrf_assert.c nrf_log.c app_error_weak.c app_util_platform.c sdk_mapped_flags.c
    ../../../../nRF5_SDK_11.0.0/components/libraries/fifo/: app_fifo.c
    ../../../../nRF5_SDK_11.0.0/components/libraries/timer/: app_timer.c
    ../../../../nRF5_SDK_11.0.0/components/libraries/trace/: app_trace.c
    ../../../../nRF5_SDK_11.0.0/components/libraries/uart/: retarget.c
    ../../../../nRF5_SDK_11.0.0/components/libraries/fstorage/: fstorage.c fstorage_nosd.c
    ../../../../nRF5_SDK_11.0.0/components/ble/ble_debug_assert_handler/: ble_debug_assert_handler.c
  group nRF_SoftDevice
    ../../../../nRF5_SDK_11.0.0/components/softdevice/s132/doc/: s132_nrf52_2.0.0-7.alpha_licence_agreement.txt
    ../../../../nRF5_SDK_11.0.0/components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group IMU libraries
    ../../../drivers/: i2cdev.c mpu6500.c max17043.c imu_cf2.c ak8963.c filter.c lps25h.c ms5611.c
    ../../../modules/: helper_3dmath.c MPU6050_6Axis_MotionApps20.c sensfusion6.c
    ../../../../nRF5_SDK_11.0.0/components/drivers_nrf/twi_master/: nrf_drv_twi.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.6.0
